# Keil uVision project qspy.uvprojx, settings and files
target dbg (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: qspy
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\qpc\include;.\qpc\ports\arm-cm\qv\armclang
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: bsp.c bsp.h main.c TM4C123GH6PM_QL.h
  group QPC
    ./qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ./qpc/src/qv/: qv.c
  group QPC-port
    ./qpc/ports/arm-cm/qv/armclang/: qp_port.h qs_port.h qv_port.c
  group QS
    ./qpc/src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c qstamp.c qutest.c
target spy (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: qspy
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: Q_SPY
  c include: .\qpc\include;.\qpc\ports\arm-cm\qv\armclang
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.1
