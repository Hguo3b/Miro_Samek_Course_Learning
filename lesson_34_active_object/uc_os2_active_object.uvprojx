# Keil uVision project uc_os2_active_object.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uc_os2_active_object
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\ucos2\Source;.;.\ucos2\Ports\ARM-Cortex-M\ARMv7-M\ARM
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: bsp.c bsp.h main.c uc_ao.c uc_ao.h TM4C123GH6PM.h
  group uCOS-II
    ./ucos2/Source/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_trace.h ucos_ii.h
  group uCOS-II_port
    ./ucos2/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ./ucos2/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu.h os_cpu_a.asm os_dbg.c
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.1
